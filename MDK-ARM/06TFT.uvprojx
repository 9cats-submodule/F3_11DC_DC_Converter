# Keil uVision project 06TFT.uvprojx, settings and files
target 06TFT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 04RNF24L01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/F1_LCD_Driver/Inc;../Drivers/F1_TOUCH_Driver/Inc;../Drivers/F1_W24QXX_Driver/Inc;../Drivers/TFT_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c stm32f1xx_it.c stm32f1xx_hal_msp.c base.c usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/F1_LCD_Driver
    ../Drivers/F1_LCD_Driver/Src/: lcd.c fontupd.c text.c
  group Drivers/F1_TOUCH_Driver
    ../Drivers/F1_TOUCH_Driver/Src/: 24cxx.c ctiic.c ft5206.c gt9147.c myiic.c ott2001a.c touch.c
  group Drivers/F1_W25QXX_Driver
    ../Drivers/F1_W24QXX_Driver/Src/: w25qxx.c
  group Drivers/TFT_Driver
    ../Drivers/TFT_Driver/Src/: cmd_process.c cmd_queue.c hmi_driver.c hmi_user_uart.c
software components: CMSIS:CORE 4.3.0
